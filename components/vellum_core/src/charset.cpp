#include "vellum/charset.h"

#include "vellum/xml.h"

namespace vellum::charset {
namespace {

// Code points of bytes 0x80..0xFF in each one-byte code page; U+FFFD where
// the code page leaves a byte unused. Made with Python's codecs module.
constexpr uint16_t kWindows1257[128] = {
    0x20AC, 0xFFFD, 0x201A, 0xFFFD, 0x201E, 0x2026, 0x2020, 0x2021, 0xFFFD, 0x2030, 0xFFFD, 0x2039, 0xFFFD,
    0x00A8, 0x02C7, 0x00B8, 0xFFFD, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, 0xFFFD, 0x2122,
    0xFFFD, 0x203A, 0xFFFD, 0x00AF, 0x02DB, 0xFFFD, 0x00A0, 0xFFFD, 0x00A2, 0x00A3, 0x00A4, 0xFFFD, 0x00A6,
    0x00A7, 0x00D8, 0x00A9, 0x0156, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x00C6, 0x00B0, 0x00B1, 0x00B2, 0x00B3,
    0x00B4, 0x00B5, 0x00B6, 0x00B7, 0x00F8, 0x00B9, 0x0157, 0x00BB, 0x00BC, 0x00BD, 0x00BE, 0x00E6, 0x0104,
    0x012E, 0x0100, 0x0106, 0x00C4, 0x00C5, 0x0118, 0x0112, 0x010C, 0x00C9, 0x0179, 0x0116, 0x0122, 0x0136,
    0x012A, 0x013B, 0x0160, 0x0143, 0x0145, 0x00D3, 0x014C, 0x00D5, 0x00D6, 0x00D7, 0x0172, 0x0141, 0x015A,
    0x016A, 0x00DC, 0x017B, 0x017D, 0x00DF, 0x0105, 0x012F, 0x0101, 0x0107, 0x00E4, 0x00E5, 0x0119, 0x0113,
    0x010D, 0x00E9, 0x017A, 0x0117, 0x0123, 0x0137, 0x012B, 0x013C, 0x0161, 0x0144, 0x0146, 0x00F3, 0x014D,
    0x00F5, 0x00F6, 0x00F7, 0x0173, 0x0142, 0x015B, 0x016B, 0x00FC, 0x017C, 0x017E, 0x02D9,
};

constexpr uint16_t kWindows1252[128] = {
    0x20AC, 0xFFFD, 0x201A, 0x0192, 0x201E, 0x2026, 0x2020, 0x2021, 0x02C6, 0x2030, 0x0160, 0x2039, 0x0152,
    0xFFFD, 0x017D, 0xFFFD, 0xFFFD, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, 0x02DC, 0x2122,
    0x0161, 0x203A, 0x0153, 0xFFFD, 0x017E, 0x0178, 0x00A0, 0x00A1, 0x00A2, 0x00A3, 0x00A4, 0x00A5, 0x00A6,
    0x00A7, 0x00A8, 0x00A9, 0x00AA, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x00AF, 0x00B0, 0x00B1, 0x00B2, 0x00B3,
    0x00B4, 0x00B5, 0x00B6, 0x00B7, 0x00B8, 0x00B9, 0x00BA, 0x00BB, 0x00BC, 0x00BD, 0x00BE, 0x00BF, 0x00C0,
    0x00C1, 0x00C2, 0x00C3, 0x00C4, 0x00C5, 0x00C6, 0x00C7, 0x00C8, 0x00C9, 0x00CA, 0x00CB, 0x00CC, 0x00CD,
    0x00CE, 0x00CF, 0x00D0, 0x00D1, 0x00D2, 0x00D3, 0x00D4, 0x00D5, 0x00D6, 0x00D7, 0x00D8, 0x00D9, 0x00DA,
    0x00DB, 0x00DC, 0x00DD, 0x00DE, 0x00DF, 0x00E0, 0x00E1, 0x00E2, 0x00E3, 0x00E4, 0x00E5, 0x00E6, 0x00E7,
    0x00E8, 0x00E9, 0x00EA, 0x00EB, 0x00EC, 0x00ED, 0x00EE, 0x00EF, 0x00F0, 0x00F1, 0x00F2, 0x00F3, 0x00F4,
    0x00F5, 0x00F6, 0x00F7, 0x00F8, 0x00F9, 0x00FA, 0x00FB, 0x00FC, 0x00FD, 0x00FE, 0x00FF,
};

constexpr uint16_t kIso8859_13[128] = {
    0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD,
    0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD,
    0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0xFFFD, 0x00A0, 0x201D, 0x00A2, 0x00A3, 0x00A4, 0x201E, 0x00A6,
    0x00A7, 0x00D8, 0x00A9, 0x0156, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x00C6, 0x00B0, 0x00B1, 0x00B2, 0x00B3,
    0x201C, 0x00B5, 0x00B6, 0x00B7, 0x00F8, 0x00B9, 0x0157, 0x00BB, 0x00BC, 0x00BD, 0x00BE, 0x00E6, 0x0104,
    0x012E, 0x0100, 0x0106, 0x00C4, 0x00C5, 0x0118, 0x0112, 0x010C, 0x00C9, 0x0179, 0x0116, 0x0122, 0x0136,
    0x012A, 0x013B, 0x0160, 0x0143, 0x0145, 0x00D3, 0x014C, 0x00D5, 0x00D6, 0x00D7, 0x0172, 0x0141, 0x015A,
    0x016A, 0x00DC, 0x017B, 0x017D, 0x00DF, 0x0105, 0x012F, 0x0101, 0x0107, 0x00E4, 0x00E5, 0x0119, 0x0113,
    0x010D, 0x00E9, 0x017A, 0x0117, 0x0123, 0x0137, 0x012B, 0x013C, 0x0161, 0x0144, 0x0146, 0x00F3, 0x014D,
    0x00F5, 0x00F6, 0x00F7, 0x0173, 0x0142, 0x015B, 0x016B, 0x00FC, 0x017C, 0x017E, 0x2019,
};

constexpr uint16_t kWindows1251[128] = {
    0x0402, 0x0403, 0x201A, 0x0453, 0x201E, 0x2026, 0x2020, 0x2021, 0x20AC, 0x2030, 0x0409, 0x2039, 0x040A,
    0x040C, 0x040B, 0x040F, 0x0452, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, 0xFFFD, 0x2122,
    0x0459, 0x203A, 0x045A, 0x045C, 0x045B, 0x045F, 0x00A0, 0x040E, 0x045E, 0x0408, 0x00A4, 0x0490, 0x00A6,
    0x00A7, 0x0401, 0x00A9, 0x0404, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x0407, 0x00B0, 0x00B1, 0x0406, 0x0456,
    0x0491, 0x00B5, 0x00B6, 0x00B7, 0x0451, 0x2116, 0x0454, 0x00BB, 0x0458, 0x0405, 0x0455, 0x0457, 0x0410,
    0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D,
    0x041E, 0x041F, 0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427, 0x0428, 0x0429, 0x042A,
    0x042B, 0x042C, 0x042D, 0x042E, 0x042F, 0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437,
    0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F, 0x0440, 0x0441, 0x0442, 0x0443, 0x0444,
    0x0445, 0x0446, 0x0447, 0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F,
};

constexpr uint32_t kReplacement = 0xFFFD;

const uint16_t* table_of(Encoding e) {
  switch (e) {
    case Encoding::Windows1257:
      return kWindows1257;
    case Encoding::Windows1252:
      return kWindows1252;
    case Encoding::Iso8859_13:
      return kIso8859_13;
    case Encoding::Windows1251:
      return kWindows1251;
    default:
      return nullptr;
  }
}

// Length of the valid UTF-8 sequence at s[i] (1-4), 0 when it is malformed,
// or -1 when it is cut off by the end of the data.
int utf8_sequence(const uint8_t* s, uint32_t len, uint32_t i, uint32_t& cp) {
  const uint8_t c = s[i];
  if (c < 0x80) {
    cp = c;
    return 1;
  }
  int n;
  uint32_t min;
  if ((c & 0xE0) == 0xC0) {
    n = 2, cp = c & 0x1F, min = 0x80;
  } else if ((c & 0xF0) == 0xE0) {
    n = 3, cp = c & 0x0F, min = 0x800;
  } else if ((c & 0xF8) == 0xF0) {
    n = 4, cp = c & 0x07, min = 0x10000;
  } else {
    return 0;
  }
  for (int k = 1; k < n; ++k) {
    if (i + k >= len) return -1;
    if ((s[i + k] & 0xC0) != 0x80) return 0;
    cp = cp << 6 | (s[i + k] & 0x3F);
  }
  if (cp < min || cp > 0x10FFFF || (cp >= 0xD800 && cp <= 0xDFFF)) return 0;
  return n;
}

char lower(char c) { return (c >= 'A' && c <= 'Z') ? static_cast<char>(c + 32) : c; }

// Whether `name` equals one of the '|'-separated names in `list`, ignoring
// case, '-' and '_'.
bool name_in(std::string_view name, std::string_view list) {
  char clean[24];
  size_t n = 0;
  for (char c : name) {
    if (c == '-' || c == '_' || c == ' ') continue;
    if (n + 1 >= sizeof(clean)) return false;
    clean[n++] = lower(c);
  }
  const std::string_view want(clean, n);
  while (!list.empty()) {
    const size_t bar = list.find('|');
    if (list.substr(0, bar) == want) return true;
    list = bar == std::string_view::npos ? std::string_view{} : list.substr(bar + 1);
  }
  return false;
}

}  // namespace

Encoding detect(const uint8_t* data, uint32_t len, uint32_t& bom) {
  bom = 0;
  if (len >= 3 && data[0] == 0xEF && data[1] == 0xBB && data[2] == 0xBF) {
    bom = 3;
    return Encoding::Utf8;
  }
  if (len >= 2 && data[0] == 0xFF && data[1] == 0xFE) {
    bom = 2;
    return Encoding::Utf16LE;
  }
  if (len >= 2 && data[0] == 0xFE && data[1] == 0xFF) {
    bom = 2;
    return Encoding::Utf16BE;
  }
  // UTF-16 without a mark: most Latin text has a zero in every other byte.
  uint32_t zero_even = 0, zero_odd = 0;
  for (uint32_t i = 0; i < len; ++i) (i % 2 ? zero_odd : zero_even) += data[i] == 0;
  if (len >= 16 && zero_odd > len / 4 && zero_even * 64 <= len) return Encoding::Utf16LE;
  if (len >= 16 && zero_even > len / 4 && zero_odd * 64 <= len) return Encoding::Utf16BE;

  bool utf8 = true;
  uint32_t high = 0;  // bytes 0x80 and up
  for (uint32_t i = 0; i < len;) {
    uint32_t cp;
    const int n = utf8_sequence(data, len, i, cp);
    if (n < 0) break;  // cut off by the end of the sample
    if (n == 0) {
      utf8 = false;
      ++high;
      break;
    }
    high += n > 1;
    i += static_cast<uint32_t>(n);
  }
  if (utf8 || high == 0) return Encoding::Utf8;

  // A one-byte code page. Lithuanian in Windows-1257 is full of š, ž and ė
  // (bytes that are the rare ð, þ and ë in Western code pages).
  uint32_t baltic = 0, letters = 0, c1 = 0, latin_quotes = 0;
  for (uint32_t i = 0; i < len; ++i) {
    const uint8_t c = data[i];
    if (c >= 0xC0) ++letters;
    if (c == 0xF0 || c == 0xD0 || c == 0xFE || c == 0xDE || c == 0xEB || c == 0xCB) ++baltic;
    if (c >= 0x80 && c < 0xA0) ++c1;
    if (c == 0xA1 || c == 0xA5 || c == 0xB4) ++latin_quotes;  // ” „ “ in ISO-8859-13
  }
  if (baltic > 0 && baltic * 5 >= letters) {
    // ISO-8859-13 has no characters at 0x80..0x9F and puts its quotes higher.
    return c1 == 0 && latin_quotes > 0 ? Encoding::Iso8859_13 : Encoding::Windows1257;
  }
  return Encoding::Windows1252;
}

bool from_name(std::string_view name, Encoding& out) {
  if (name_in(name, "utf8")) {
    out = Encoding::Utf8;
  } else if (name_in(name, "utf16le|utf16")) {
    out = Encoding::Utf16LE;
  } else if (name_in(name, "utf16be")) {
    out = Encoding::Utf16BE;
  } else if (name_in(name, "windows1257|cp1257")) {
    out = Encoding::Windows1257;
  } else if (name_in(name, "windows1252|cp1252|usascii|ascii")) {
    out = Encoding::Windows1252;
  } else if (name_in(name, "iso885913|latin7")) {
    out = Encoding::Iso8859_13;
  } else if (name_in(name, "windows1251|cp1251")) {
    out = Encoding::Windows1251;
  } else if (name_in(name, "iso88591|latin1")) {
    out = Encoding::Latin1;
  } else {
    return false;
  }
  return true;
}

uint32_t to_utf8(Encoding e, const uint8_t* in, uint32_t len, char* out, uint32_t cap) {
  uint32_t w = 0;
  auto put = [&](uint32_t cp) {
    char buf[4];
    const size_t n = xml::encode_utf8(cp, buf);
    if (w + n > cap) return false;
    for (size_t k = 0; k < n; ++k) out[w++] = buf[k];
    return true;
  };
  if (e == Encoding::Utf8) {
    for (uint32_t i = 0; i < len;) {
      if (in[i] < 0x80) {
        if (w >= cap) break;
        out[w++] = static_cast<char>(in[i++]);
        continue;
      }
      uint32_t cp;
      const int n = utf8_sequence(in, len, i, cp);
      if (n < 0) break;
      if (!put(n == 0 ? kReplacement : cp)) break;
      i += n == 0 ? 1 : static_cast<uint32_t>(n);
    }
  } else if (e == Encoding::Utf16LE || e == Encoding::Utf16BE) {
    const bool le = e == Encoding::Utf16LE;
    auto at = [&](uint32_t i) { return static_cast<uint32_t>(le ? in[i] | in[i + 1] << 8 : in[i] << 8 | in[i + 1]); };
    for (uint32_t i = 0; i + 1 < len; i += 2) {
      uint32_t cp = at(i);
      if (cp >= 0xD800 && cp < 0xDC00) {
        if (i + 3 >= len) break;  // the pair is cut off
        const uint32_t lo = at(i + 2);
        if (lo >= 0xDC00 && lo < 0xE000) {
          cp = 0x10000 + ((cp - 0xD800) << 10) + (lo - 0xDC00);
          i += 2;
        } else {
          cp = kReplacement;
        }
      } else if (cp >= 0xDC00 && cp < 0xE000) {
        cp = kReplacement;
      }
      if (!put(cp)) break;
    }
  } else {
    const uint16_t* table = table_of(e);
    for (uint32_t i = 0; i < len; ++i) {
      const uint8_t c = in[i];
      if (!put(c < 0x80 || table == nullptr ? c : table[c - 0x80])) break;
    }
  }
  return w;
}

uint32_t code_point(Encoding e, uint8_t byte) {
  const uint16_t* table = table_of(e);
  return byte < 0x80 || table == nullptr ? byte : table[byte - 0x80];
}

}  // namespace vellum::charset
